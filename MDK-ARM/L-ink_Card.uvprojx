# Keil uVision project L-ink_Card.uvprojx, settings and files
target L-ink_Card (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L051K8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: L-ink_Card +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/ST25DV;../Drivers/BSP/NFC04A1;../Drivers/BSP/Drivers/BSP/NFC04A1;..\Drivers\BSP\E-Paper-Display;..\Drivers\BSP\ST25DV;..\DisPlay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_hal_exti.c custom_bus.c adc.c flash.c
    ../Drivers/BSP/E-Paper-Display/: epd_w21.c
    ../Drivers/BSP/ST25DV/: app_nfc.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ST25DV/: st25dv_reg.c st25dv.c
  group Drivers/BSP/NFC04A1
    ../Drivers/BSP/NFC04A1/: nfc04a1.c nfc04a1_nfctag.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group DisPlay
    ../DisPlay/: DEV_Config.c DisPlay.c EPD_1in54.c font8.c font12.c font12CN.c font16.c font16CN.c font20.c font24.c font24CN.c GUI_Paint.c
software components: CMSIS:CORE 4.3.0
